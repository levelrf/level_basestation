<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>heartbeat_521mhz</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>521e6</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>50e3</value></param>
</block>
<block>
<key>extras_signal_source</key>
<param><key>id</key><value>extras_signal_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>wave</key><value>COSINE</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>wave_freq</key><value>1000</value></param>
<param><key>off</key><value>0</value></param>
<param><key>scalar</key><value>1.0</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
<param><key>bt</key><value>0.35</value></param>
</block>
<block>
<key>heart_beat</key>
<param><key>id</key><value>heart_beat_0</value></param>
<param><key>period</key><value>1</value></param>
<param><key>key</key><value>W</value></param>
<param><key>value</key><value>TEST</value></param>
</block>
<connection><source_block_id>heart_beat_0</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_signal_source_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
