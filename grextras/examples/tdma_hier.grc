<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tdma_hier</value></param>
<param><key>title</key><value>TDMA_HIER</value></param>
<param><key>author</key><value>John Malsbury</value></param>
<param><key>description</key><value>USRP TDMA Implementation</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>MAC</value></param>
</block>
<block>
<key>extras_packet_deframer</key>
<param><key>id</key><value>extras_packet_deframer_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rate</value></param>
<param><key>label</key><value>S</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>label</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>args</value></param>
<param><key>label</key><value>args</value></param>
<param><key>value</key><value></value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>915e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ampl</value></param>
<param><key>label</key><value>a</value></param>
<param><key>value</key><value>0.7</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>burst_gate</key>
<param><key>id</key><value>burst_gate_0</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>ampl</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>number_of_slots</value></param>
<param><key>label</key><value>Number of Slots</value></param>
<param><key>value</key><value>10</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lead_limit</value></param>
<param><key>label</key><value>Lead Limit(s)</value></param>
<param><key>value</key><value>0.025</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>initial_slot</value></param>
<param><key>label</key><value>Initial Slot</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>link_speed</value></param>
<param><key>label</key><value>Link Speed(bps)</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>slot_interval</value></param>
<param><key>label</key><value>Slot Interval(s)</value></param>
<param><key>value</key><value>0.010</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>guard_interval</value></param>
<param><key>label</key><value>Guard Interval(s)</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>gmsk_mod</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
<param><key>bt</key><value>0.35</value></param>
</block>
<block>
<key>extras_pmt_rpc</key>
<param><key>id</key><value>extras_pmt_rpc_0</value></param>
<param><key>result_msg</key><value>False</value></param>
</block>
<block>
<key>tdma_engine</key>
<param><key>id</key><value>tdma_engine</value></param>
<param><key>initial_slot</key><value>initial_slot</value></param>
<param><key>slot_interval</key><value>slot_interval</value></param>
<param><key>guard_interval</key><value>guard_interval</value></param>
<param><key>num_slots</key><value>number_of_slots</value></param>
<param><key>lead_limit</key><value>lead_limit</value></param>
<param><key>link_bps</key><value>link_speed</value></param>
</block>
<block>
<key>extras_packet_framer</key>
<param><key>id</key><value>extras_packet_framer_0</value></param>
<param><key>samples_per_symbol</key><value>1</value></param>
<param><key>bits_per_symbol</key><value>1</value></param>
<param><key>access_code</key><value></value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pkt_in</value></param>
<param><key>label</key><value>pkt_in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>ctrl_in</value></param>
<param><key>label</key><value>ctrl_in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_gmsk_demod</key>
<param><key>id</key><value>gmsk_demod</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>freq_error</key><value>0.0</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>usrp_source</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>stream_args</key><value>serial=E8R10Z2B1</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>usrp_sink</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>stream_args</key><value>serial=E4R11Y0B1</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pkt_out</value></param>
<param><key>label</key><value>pkt_out</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>ctrl_out</value></param>
<param><key>label</key><value>ctrl_out</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>usrp_source</source_block_id><sink_block_id>tdma_engine</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tdma_engine</source_block_id><sink_block_id>extras_packet_framer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_source</source_block_id><sink_block_id>gmsk_demod</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gmsk_demod</source_block_id><sink_block_id>extras_packet_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_packet_framer_0</source_block_id><sink_block_id>gmsk_mod</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pkt_in</source_block_id><sink_block_id>tdma_engine</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ctrl_in</source_block_id><sink_block_id>tdma_engine</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>extras_packet_deframer_0</source_block_id><sink_block_id>pkt_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gmsk_mod</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>burst_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>burst_gate_0</source_block_id><sink_block_id>usrp_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_packet_deframer_0</source_block_id><sink_block_id>tdma_engine</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>ctrl_in</source_block_id><sink_block_id>extras_pmt_rpc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tdma_engine</source_block_id><sink_block_id>ctrl_out</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
