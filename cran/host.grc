<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>host</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>125e3</value></param>
</block>
<block>
<key>extras_socket_to_blob</key>
<param><key>id</key><value>extras_socket_to_blob_0</value></param>
<param><key>proto</key><value>TCP</value></param>
<param><key>addr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>5000</value></param>
<param><key>mtu</key><value>0</value></param>
</block>
<block>
<key>extras_blob_to_stream</key>
<param><key>id</key><value>extras_blob_to_stream_0</value></param>
<param><key>item_size</key><value>8</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>868E6</value></param>
<param><key>gain0</key><value>5</value></param>
<param><key>ant0</key><value></value></param>
<param><key>bw0</key><value>200e3</value></param>
</block>
<connection><source_block_id>extras_blob_to_stream_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_socket_to_blob_0</source_block_id><sink_block_id>extras_blob_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
