<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>host</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>125e3</value></param>
</block>
<block>
<key>extras_socket_to_blob</key>
<param><key>id</key><value>extras_socket_to_blob_0</value></param>
<param><key>proto</key><value>TCP</value></param>
<param><key>addr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>5000</value></param>
<param><key>mtu</key><value>0</value></param>
</block>
<block>
<key>extras_blob_to_stream</key>
<param><key>id</key><value>extras_blob_to_stream_0</value></param>
<param><key>item_size</key><value>8</value></param>
</block>
<block>
<key>digital_gmsk_demod</key>
<param><key>id</key><value>digital_gmsk_demod_0</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>freq_error</key><value>0.0</value></param>
</block>
<connection><source_block_id>extras_socket_to_blob_0</source_block_id><sink_block_id>extras_blob_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_blob_to_stream_0</source_block_id><sink_block_id>digital_gmsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
